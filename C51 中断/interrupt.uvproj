# Keil uVision project interrupt.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: interrupt
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 delay.c IntConfig.c INTCONFIG.H main.c tube.c TUBE.H DELAY.H
